; Input two 2-digit HEX numbers from the keyboard. Display each
; number in the data field and when NEXT key is pressed display
; their product in the address field of the display.

START:
	MOV R0, #02H 			; 78 02 	; NUMBER OF INPUTS

INPUT:
	LCALL RDKBD 			; 12 02 A2 	; READ FIRST NIBBLE
	MOV B, A 				; F5 F0 	; SAVE IN REG (B)
	LCALL RDKBD 			; 12 02 A2 	; READ SECOND NIBBLE
	SWAP A 					; C4 		; SWAP FOR PACKING
	ORL A, B 				; 45 F0 	; PACK THE NUMBER
	PUSH ACC 				; C0 E0 	; SAVE A COPY OF THE INPUT IN STACK
	MOV 60H, A 				; F5 60 	; DISPLAY PLACEHOLDER
	MOV B, #00H 			; 75 F0 00 	; NO DOT IN DISPLAY
	LCALL UPDDT	 			; 12 01 9B 	; DISPLAY IN DATA FIELD

	DJNZ R0, INPUT 			; D8 _E9	; TAKE TWO INPUTS

	LCALL RDKBD 			; 12 02 A2 	; READ FOR NEXT KEYPRESS
	CJNE A, #14H, START 	; B4 14 _E1 ; REPEAT PROGRAM, IF NOT PRESSED NEXT KEY

	POP ACC					; D0 E0 	; GET SECOND NUMBER
	MOV B, A				; F5 F0 	; LOAD IN REG (B)
	POP ACC 				; D0 E0 	; GET FIRST NUMBER
	MUL AB 					; A4 		; MULTIPLY THE INPUTS

	MOV 60H, A 				; F5 60 	; FOR DISPLAYING LOWER NIBBLE OF PRODUCT
	MOV 61H, B				; 85 F0 61 	; FOR DISPLAYING UPPER NIBBLE OF PRODUCT
	MOV B, #00H 			; 75 F0 00 	; NO DOT IN DISPLAY
	LCALL UPDAD				; 12 02 0B 	; DISPLAY IN ADDRESS FIELD

	LJMP START 				; 12 80 00 	; REPEAT THE PROGRAM

RDKBD:
	RET
UPDDT:
	RET
UPDAD:
	RET
