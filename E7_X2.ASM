; Input a 4-digit HEX address of a memory location from
; the keyboard and display its content in the data field
; of the display when “NEXT” key is pressed.

; LITTLE ENDIAN CONVENTION

START:
	MOV R0, #04H 				; 78 04 	; REPEAT COUNT
	INPUT:
		LCALL RDKBD 	 		; 12 02 A2 	; READ KEYBOARD
		PUSH ACC  				; C0 E0 	; SAVE INPUT CHARACTER
		DJNZ R0, INPUT 			; D8 _F9 	; REPEAT IN A LOOP

		LCALL RDKBD				; 12 02 A2 	; CHECK FOR NEXT KEY PRESS
		CJNE A, #14H, START 	; B4 14 _F1	; BREAK OUT IF NEXT KEY NOT PRESSED

	MOV R0, #83H 				; 78 83 	; TO PACK DATA TO (DPH, DPL)
	PACK:
		POP ACC  				; D0 E0 	; GET HIGHER NIBBLE
		SWAP A 					; C4 		; SWAP TO ALLOW FOR PACKING DATA
		MOV @R0, A 				; F6 		; MOVE TO DESTINATION (DP_)

		POP ACC 				; D0 E0 	; GET LOWER NIBBLE
		ORL A, @R0				; 46 		; PACK THE DATA, STORE IN ACCUMULATOR
		MOV @R0, A 				; F6	 	; MOVE TO DESTINATION (DP_)

		DEC R0 					; 18 		; DECREMENT TO POINT TO PREVIOUS ADDRESS
		CJNE @R0, #81H, PACK 	; B6 81 _F4	; CHECK IF DONE TWICE? FOR (DPH, DPL)

	MOVX A, @DPTR 				; E0 		; GET DATA FROM INPUTTED LOCATION
	MOV 60H, A 					; F5 60  	; DISPLAY PLACEHOLDER
	LCALL UPDDT 				; 12 01 9B 	; DISPLAY ROUTINE

RDKBD:
	RET
UPDDT:
	RET
